# IAR project ez430_chronos_access_point.ewp, settings and files
configuration 915MHz - Unrestricted IAR Workbench (USA) (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5509 MSP430F5509
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430F5509__; BSP_NO_BUTTONS; MRFI_CC1101; ISM_US
  ICC430.IExtraOptions: -f"simpliciti\Configuration\Access Point\smpl_config.dat"; -f"simpliciti\Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: ; bluerobin\; F5xx_F6xx_Core_Lib\; simpliciti\; simpliciti\Components\bsp\; simpliciti\Components\bsp\boards\EZ430-CHRONOS_DONGLE\; simpliciti\Components\bsp\boards\EZ430-CHRONOS_DONGLE\bsp_external\; simpliciti\Components\bsp\drivers\; simpliciti\Components\bsp\drivers\code\; simpliciti\Components\bsp\mcus\; simpliciti\Components\mrfi\; simpliciti\Components\mrfi\radios\common\; simpliciti\Components\mrfi\radios\family1\; simpliciti\Components\mrfi\smartrf\CC1101\; simpliciti\Components\nwk\; simpliciti\Components\nwk_applications\; USB_API\USB_CDC_API\; USB_API\USB_Common\; USB_config\; WBSL\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5509.xcl
  XLINK.XlinkStackSize: 1
configuration 915MHz - Limited IAR KickStart (USA) (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  XLINK.XExtraOptions: --ks_version
configuration 868MHz - Unrestricted IAR Workbench (Europe) (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __MSP430F5509__; BSP_NO_BUTTONS; MRFI_CC1101; ISM_EU
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5509.xcl
configuration 868MHz - Limited IAR KickStart (Europe) (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  ICC430.CCDefines: __MSP430F5509__; BSP_NO_BUTTONS; MRFI_CC1101; ISM_EU
  XLINK.XExtraOptions: --ks_version
configuration 433MHz - Unrestricted IAR Workbench (Other Regions) (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  ICC430.CCDefines: __MSP430F5509__; BSP_NO_BUTTONS; MRFI_CC1101; ISM_LF
configuration 433MHz - Limited IAR KickStart (Other Regions) (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  ICC430.CCDefines: __MSP430F5509__; BSP_NO_BUTTONS; MRFI_CC1101; ISM_LF
  XLINK.XExtraOptions: --ks_version
  group (top)
    ./: BM_API.h ccSPI.c ccSPI.h ccxx00.h change_record.txt cmdHandler.c cmdHandler.h main.c project.h usbConstructs.c usbConstructs.h usbEventHandling.c
  group bluerobin
    bluerobin/: BlueRobin_TX_433MHz.r43 BlueRobin_TX_868MHz.r43 BlueRobin_TX_915MHz.r43 BlueRobin_TX_API.h bm.h timer.c
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group simpliciti
    simpliciti/: AP_MSP430F5509_CC1101_433MHz.r43 AP_MSP430F5509_CC1101_868MHz.r43 AP_MSP430F5509_CC1101_915MHz.r43 simpliciti.h simpliciti_readme.txt
  group simpliciti/Applications
    simpliciti/Applications/: main_AP_BM.c
  group simpliciti/Components/bsp
    simpliciti/Components/bsp/: bsp.c bsp.h bsp_macros.h
  group simpliciti/Components/bsp/boards/EZ430-CHRONOS_DONGLE
    simpliciti/Components/bsp/boards/EZ430-CHRONOS_DONGLE/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_config.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
  group simpliciti/Components/bsp/boards/EZ430-CHRONOS_DONGLE/bsp_external
    simpliciti/Components/bsp/boards/EZ430-CHRONOS_DONGLE/bsp_external/: mrfi_board.c mrfi_board_defs.h
  group simpliciti/Components/bsp/drivers
    simpliciti/Components/bsp/drivers/: bsp_buttons.h bsp_leds.h
  group simpliciti/Components/bsp/drivers/code
    simpliciti/Components/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
  group simpliciti/Components/bsp/mcus
    simpliciti/Components/bsp/mcus/: bsp_msp430_defs.h
  group simpliciti/Components/mrfi
    simpliciti/Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group simpliciti/Components/mrfi/radios/common
    simpliciti/Components/mrfi/radios/common/: mrfi_f1f2.c mrfi_f1f2.h
  group simpliciti/Components/mrfi/radios/family1
    simpliciti/Components/mrfi/radios/family1/: mrfi_radio.c mrfi_spi.c mrfi_spi.h
  group simpliciti/Components/mrfi/smartrf/CC1101
    simpliciti/Components/mrfi/smartrf/CC1101/: smartrf_CC1101.h
  group simpliciti/Components/nwk
    simpliciti/Components/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group simpliciti/Components/nwk_applications
    simpliciti/Components/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
  group simpliciti/Configuration
    simpliciti/Configuration/: smpl_nwk_config.dat
  group simpliciti/Configuration/Access Point
    simpliciti/Configuration/Access Point/: smpl_config.dat
  group USB_API/USB_CDC_API
    USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
  group USB_API/USB_HID_API
    USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group USB_API/USB_MSC_API
    USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group USB_API/USB_PHDC_API
    USB_API/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group USB_config
    USB_config/: descriptors.c descriptors.dat descriptors.h UsbIsr.c
  group WBSL
    WBSL/: spi_wbsl.c spi_wbsl.h wbsl.c wbsl.h
